# IAR project MED-EKG K53.ewp, settings and files
configuration RAM Debug K40 (ARM, debug)
  General.OGChipSelectEditMenu: Default None
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 0
  ICCARM.CCIncludePath2: ; ..\..\; ..\..\..\common; ..\..\..\common\kinetis; ..\..\..\..\source\driver; ..\..\..\..\source\driver\kinetis; ..\..\..\..\source\common; ..\..\..\..\source\class; ..\..\..\..\app\cdc\iar_ew\kinetis\MED_EKG_FILES\APP; ..\..\..\..\app\cdc\iar_ew\kinetis\MED_EKG_FILES\APP\Med-EKG; ..\..\..\..\app\cdc\iar_ew\kinetis\MED_EKG_FILES\LL_DRIVERS
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: c.srec
  ILINK.IlinkOutputFile: $PROJ_FNAME$.out
  ILINK.IlinkIcfFile: config\MK40N512VMD100_RAM.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Flash Debug K40 (ARM, debug)
  as the first configuration, except:
  General.OGChipSelectEditMenu: MK40DX256Zxxx10 Freescale MK40DX256Zxxx10
  ILINK.IlinkIcfFile: config\MK40N512VMD100_Flash.icf
  group (top)
    ./: readme.txt
  group app
    ../../../common/: main_kinetis.c
    ../../../common/kinetis/: RealTimerCounter_kinetis.c wdt_kinetis.c
    ../../: usb_descriptor.c
  group class
    ../../../../source/class/: usb_cdc.c usb_cdc_pstn.c
    ../../../../source/common/: usb_class.c
  group driver
    ../../../../source/driver/kinetis/: usb_dci_kinetis.c
    ../../../../source/driver/: usb_driver.c
    ../../../../source/common/: usb_framework.c
  group MED_EKG/APP
    MED_EKG_FILES/APP/Med-EKG/: AverageFilter.c AverageFilter.h Bluetooth.c Bluetooth.h Ecg.c ECG.h HeartRate.c HeartRate.h PublicTypes.h SerialCommands.h
    MED_EKG_FILES/APP/: dsp.h dsp.s ekg.c ekg.h Kinetis_FIR.c Kinetis_FIR.h Kinetis_FTM.c Kinetis_FTM.h TWR_K50_UI.h
  group MED_EKG/Drivers
    MED_EKG_FILES/LL_DRIVERS/: ADC.c ADC.h DAC.c DAC.h IICV1Driver.c IICV1Driver.h IICV1HAL_K50.h OPAMP.c OPAMP.h uart.c uart.h
  group prm
    config/: MK40N512VMD100_Flash.icf MK40N512VMD100_RAM.icf
  group startup
    ./: cstartup_M.s low_level_init.c
