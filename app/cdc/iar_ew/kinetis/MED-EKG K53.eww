<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\MED-EKG K53.ewp</path>
  </project>
  <batchBuild>
    <batchDefinition>
      <name>All</name>
      <member>
        <project>USB_CDC</project>
        <configuration>Flash Debug K40</configuration>
      </member>
      <member>
        <project>USB_CDC</project>
        <configuration>Flash Debug K60</configuration>
      </member>
      <member>
        <project>USB_CDC</project>
        <configuration>RAM Debug K40</configuration>
      </member>
      <member>
        <project>USB_CDC</project>
        <configuration>RAM Debug K60</configuration>
      </member>
    </batchDefinition>
  </batchBuild>
</workspace>


